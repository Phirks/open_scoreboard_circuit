# Repository Phirks/open_scoreboard_circuit (continued)

## KiCad design Scoreboard.kicad_pcb (continued)

Parts:
D30, D31, D32, D33, D34, D35, D36, D37, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D155, D156, D157, D158, D159, D160, D161, D162, D163: LED_RGAB; RGB_LED_NH-B2020RGBA-HF; Part Number NH-B2020RGBA-HF; LCSC Part Number C2874116

Connections:
BLUE_RIGHT_1: D30.2 (GK), D31.2 (GK), D32.2 (GK), D33.2 (GK), D34.2 (GK), D35.2 (GK), D36.2 (GK), D37.2 (GK), D41.2 (GK), D42.2 (GK), D43.2 (GK), D44.2 (GK), D45.2 (GK), D46.2 (GK), D47.2 (GK), D48.2 (GK), D49.2 (GK), D50.2 (GK), D51.2 (GK), D52.2 (GK), D53.2 (GK), D54.2 (GK), D55.2 (GK), D56.2 (GK), D57.2 (GK), D58.2 (GK), D59.2 (GK), D60.2 (GK), D61.2 (GK), D62.2 (GK), D63.2 (GK), D64.2 (GK), D65.2 (GK), D66.2 (GK), D67.2 (GK), D68.2 (GK), D155.2 (GK), D156.2 (GK), D157.2 (GK), D158.2 (GK), D159.2 (GK), D160.2 (GK), D161.2 (GK), D162.2 (GK), D163.2 (GK); also elsewhere on the board
GREEN_RIGHT_1: D30.4 (BK), D31.4 (BK), D32.4 (BK), D33.4 (BK), D34.4 (BK), D35.4 (BK), D36.4 (BK), D37.4 (BK), D41.4 (BK), D42.4 (BK), D43.4 (BK), D44.4 (BK), D45.4 (BK), D46.4 (BK), D47.4 (BK), D48.4 (BK), D49.4 (BK), D50.4 (BK), D51.4 (BK), D52.4 (BK), D53.4 (BK), D54.4 (BK), D55.4 (BK), D56.4 (BK), D57.4 (BK), D58.4 (BK), D59.4 (BK), D60.4 (BK), D61.4 (BK), D62.4 (BK), D63.4 (BK), D64.4 (BK), D65.4 (BK), D66.4 (BK), D67.4 (BK), D68.4 (BK), D155.4 (BK), D156.4 (BK), D157.4 (BK), D158.4 (BK), D159.4 (BK), D160.4 (BK), D161.4 (BK), D162.4 (BK), D163.4 (BK); also elsewhere on the board
RED_RIGHT_1: D30.1 (RK), D31.1 (RK), D32.1 (RK), D33.1 (RK), D34.1 (RK), D35.1 (RK), D36.1 (RK), D37.1 (RK), D41.1 (RK), D42.1 (RK), D43.1 (RK), D44.1 (RK), D45.1 (RK), D46.1 (RK), D47.1 (RK), D48.1 (RK), D49.1 (RK), D50.1 (RK), D51.1 (RK), D52.1 (RK), D53.1 (RK), D54.1 (RK), D55.1 (RK), D56.1 (RK), D57.1 (RK), D58.1 (RK), D59.1 (RK), D60.1 (RK), D61.1 (RK), D62.1 (RK), D63.1 (RK), D64.1 (RK), D65.1 (RK), D66.1 (RK), D67.1 (RK), D68.1 (RK), D155.1 (RK), D156.1 (RK), D157.1 (RK), D158.1 (RK), D159.1 (RK), D160.1 (RK), D161.1 (RK), D162.1 (RK), D163.1 (RK); also elsewhere on the board
Segment_A: D49.3 (A), D52.3 (A), D55.3 (A), D58.3 (A), D159.3 (A); also elsewhere on the board
Segment_B: D61.3 (A), D62.3 (A), D63.3 (A), D64.3 (A), D162.3 (A); also elsewhere on the board
Segment_C: D65.3 (A), D66.3 (A), D67.3 (A), D68.3 (A), D163.3 (A); also elsewhere on the board
Segment_D: D51.3 (A), D54.3 (A), D57.3 (A), D60.3 (A), D161.3 (A); also elsewhere on the board
Segment_E: D45.3 (A), D46.3 (A), D47.3 (A), D48.3 (A), D158.3 (A); also elsewhere on the board
Segment_F: D41.3 (A), D42.3 (A), D43.3 (A), D44.3 (A), D157.3 (A); also elsewhere on the board
Segment_G: D50.3 (A), D53.3 (A), D56.3 (A), D59.3 (A), D160.3 (A); also elsewhere on the board
Segment_H: D34.3 (A), D35.3 (A), D36.3 (A), D37.3 (A), D156.3 (A); also elsewhere on the board
Segment_I: D30.3 (A), D31.3 (A), D32.3 (A), D33.3 (A), D155.3 (A); also elsewhere on the board

Board: 2 copper layers, 140.5 x 64.5 mm, 237 parts (4 on the bottom side), 71 nets.

## Commit log

2024-11-19 Made a new hardware revision
2024-12-18 new version with indexed leds
2024-12-18 last updates for sending to PCBway
2025-03-23 Created hardware revision 0.3, sent to fab.
2025-04-01 changes made to footprints
2025-04-01 Resolved all changes in the PCB
2025-04-06 still some issues with pcb file
2025-04-06 Fixed missing ground connection
